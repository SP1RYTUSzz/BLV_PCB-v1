# Repository SP1RYTUSzz/BLV_PCB-v1

## KiCad design BLV_PCB.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1, J2, J3: Cube0 JST-PH; JST_PH_S4B-PH-K_1x04_P2.00mm_Horizontal
J4: Micro_SD_Card; microSD_HC_Wuerth_693072010801

Connections:
+3V3: J4.4 (VDD); also elsewhere on the board
/GNSS/SPI_CS: J4.2 (DAT3/CD); also elsewhere on the board
/GNSS/SPI_MISO: J4.7 (DAT0); also elsewhere on the board
/GNSS/SPI_MOSI: J4.3 (CMD); also elsewhere on the board
/GNSS/SPI_SCK: J4.5 (CLK); also elsewhere on the board
/MCU/CUBE_UART0_RX: J1.2; also elsewhere on the board
/MCU/CUBE_UART0_TX: J1.1; also elsewhere on the board
/MCU/CUBE_UART1_RX: J2.2; also elsewhere on the board
/MCU/CUBE_UART1_TX: J2.1; also elsewhere on the board
/MCU/CUBE_UART2_RX: J3.2; also elsewhere on the board
/MCU/CUBE_UART2_TX: J3.1; also elsewhere on the board
GND: J1.4, J2.4, J3.4, J4.6 (VSS), J4.9 (SHIELD); also elsewhere on the board

Notes on the sheet:
Check with BLV requirements matrix
MicroSD (SPI Mode)

Parts:
BT1: 18650 LiPo; 18650-PC4
C17, C18: 10u; C_0603_1608Metric
C19, C20: 10u; C_0402_1005Metric
C21, C23, C24, C25: 22u; C_0805_2012Metric
C22: 10u; C_0805_2012Metric
D4: YELLOW; LED_0805_2012Metric
D5: SS36-E3/57T; D_SMC
D6: YELLOW; LED_0603_1608Metric
D7: GREEN; LED_0603_1608Metric
J6: USB_C_USB2.0_16P; USB_C_Receptacle_Molex_105450-0101
L2: 1u; IND-SMD_L4.0-W4.0_XFL4020-102MEB; LCSC Part C5355380
Q1: Si2301CDS; SOT-23
R15, R16: 5k1; R_0402_1005Metric
R17: 5K1; R_0402_1005Metric
R18: 2k2; R_0402_1005Metric
R19: 10k; R_0603_1608Metric
R20: 200k; R_0402_1005Metric
R21: 49k9; R_0402_1005Metric
R22, R23: 2k2; R_0603_1608Metric
SW3: CHRG_EN
U3: TP4056; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.3mm_ThermalVias
U4: AMS1117-3.3; SOT-223-3_TabPin2
U5: TPS61230DRCR; Texas_S-PVSON-N10_ThermalVias

Connections:
+3V3: C20.1, D6.2 (A), U4.2 (VO); also elsewhere on the board
+5V: C23.1, C24.1, C25.1, D7.2 (A), R20.1, U5.3 (VOUT), U5.4 (VOUT); also elsewhere on the board
+BATT: BT1.1 (+), C18.1, Q1.3 (D), U3.5 (BAT)
/Power/CE: SW3.2 (B), U3.8 (CE)
/Power/CHRG_LED: D4.1 (K), R17.1
/Power/LED_3V3: D6.1 (K), R22.2
/Power/LED_5V: D7.1 (K), R23.2
/Power/PROG: R18.1, U3.2 (PROG)
/Power/USB1_CC1: J6.A5 (CC1), R16.1
/Power/USB1_CC2: J6.B5 (CC2), R15.1
/Power/~CHRG: R17.2, U3.7 (~CHRG)
GND: BT1.2 (-), C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, J6.A1 (GND), J6.A12 (GND), J6.B1 (GND), J6.B12 (GND), R15.2, R16.2, R18.2, R19.2, R21.2, R22.1, R23.1, SW3.3 (C), U3.1 (TEMP), U3.3 (GND), U3.6 (~STDBY), U4.1 (GND), U5.11 (GND); also elsewhere on the board
unnamed: C19.1, C21.1, D5.1 (K), L2.1, Q1.2 (S), U4.3 (VI), U5.9 (EN), U5.10 (VIN)
unnamed: L2.2, U5.1 (SW), U5.2 (SW)
unnamed: R20.2, R21.1, U5.7 (FB)
unnamed: C22.1, U5.6 (SS)
USB_D+: J6.A6 (D+), J6.B6 (D+); also elsewhere on the board
USB_D-: J6.A7 (D-), J6.B7 (D-); also elsewhere on the board
VBUS: C17.1, D4.2 (A), D5.2 (A), J6.A4 (VBUS), J6.A9 (VBUS), J6.B4 (VBUS), J6.B9 (VBUS), Q1.1 (G), R19.1, SW3.1 (A), U3.4 (V_{CC})

Notes on the sheet:
USB-C Negotiation CC1/CC2 Pull-down 5V @ 1A (nominal) 5V @ 3A (with USB-PD)
Refer to Microchip AN1149
CHRG_EN Switch ON to charge when USB plugged in
Rprog = 1100/Ibat 5k1 - 0.216A 2k2 - 0.5A
Linear +3V3 @ 1A
Vin: ~4.5V (USB) 3.0-4.2V (VBATT)
Line Switcher
Leave shield floating
Gate pulldown Avoid floating gate
TVS anywhere?
Batt Charger @ 500mA
Model SYSTEM SW like "remove before flight" pin
SMPS +5V @ 2A
18650 LiPo
USB-C
Schottky Rectifier 0.45V Forward drop @ 1A, 25C 0.55V Forward drop @ 3A, 25C Tjunction higher = decrease VF

Notes on the sheet:
Temp Sensor?

Parts:
C1, C3, C4, C5, C6, C7, C8, C9, C10, C14: 100n; C_0402_1005Metric
C2, C12, C13: 4u7; C_0603_1608Metric
C11: 4u7; C_0402_1005Metric
C15, C16: 15p; C_0402_1005Metric
D1, D2, D3: GREEN; LED_0805_2012Metric
J5: Dupont Debug Headers; PinHeader_1x03_P2.54mm_Vertical
L1: 3.3u; L_pol_2016
R1: 33; R_0402_1005Metric
R2, R3: 27; R_0402_1005Metric
R4, R8, R9, R10: 10k; R_0402_1005Metric
R5: DNF; R_0402_1005Metric
R6: 1k; R_0603_1608Metric
R7: 0; R_0402_1005Metric
R11: 1k; R_0402_1005Metric
R12, R13, R14: 1k; R_0805_2012Metric
SW1, SW2: SW_Push; SW_SPST_B3U-1000P
U1: W25Q128JVS; SOIC-8_5.3x5.3mm_P1.27mm
U2: RP2350_60QFN; QFN-60-1EP_7x7mm_P0.4mm_EP3.4x3.4mm_ThermalVias
Y1: ABM8_262_T3; Crystal_SMD_Abracon_ABM8G-4Pin_3.2x2.5mm

Connections:
+1V1: C1.1, C2.1, C3.1, C13.1, L1.1, U2.6 (DVDD), U2.23 (DVDD), U2.39 (DVDD), U2.50 (VREG_FB)
+3V3: C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C12.1, C14.1, R1.1, R4.1, R8.2, R9.2, SW2.2, U1.8 (VCC), U2.1 (IOVDD), U2.11 (IOVDD), U2.20 (IOVDD), U2.26 (RUN), U2.30 (IOVDD), U2.38 (IOVDD), U2.44 (ADC_AVDD), U2.45 (IOVDD), U2.49 (VREG_VIN), U2.53 (USB_OTP_VDD), U2.54 (QSPI_IOVDD); also elsewhere on the board
/GNSS/SPI_CS: U2.17 (GPIO13); also elsewhere on the board
/GNSS/SPI_MISO: U2.16 (GPIO12); also elsewhere on the board
/GNSS/SPI_MOSI: U2.19 (GPIO15); also elsewhere on the board
/GNSS/SPI_SCK: U2.18 (GPIO14); also elsewhere on the board
/MCU/BUS_I2C0_SCL: R9.1, U2.37 (GPIO25)
/MCU/BUS_I2C0_SDA: R8.1, U2.36 (GPIO24)
/MCU/CUBE_UART0_RX: U2.3 (GPIO1); also elsewhere on the board
/MCU/CUBE_UART0_TX: U2.2 (GPIO0); also elsewhere on the board
/MCU/CUBE_UART1_RX: U2.8 (GPIO5); also elsewhere on the board
/MCU/CUBE_UART1_TX: U2.7 (GPIO4); also elsewhere on the board
/MCU/CUBE_UART2_RX: U2.13 (GPIO9); also elsewhere on the board
/MCU/CUBE_UART2_TX: U2.12 (GPIO8); also elsewhere on the board
/MCU/FLASH_SS: R4.2, R5.2, R7.2, U1.1 (~CS)
/MCU/QSPI_SCLK: U1.6 (CLK), U2.56 (QSPI_SCLK)
/MCU/QSPI_SD0: U1.5 (DI(IO0)), U2.57 (QSPI_SD0)
/MCU/QSPI_SD1: U1.2 (DO(IO1)), U2.59 (QSPI_SD1)
/MCU/QSPI_SD2: U1.3 (IO2), U2.58 (QSPI_SD2)
/MCU/QSPI_SD3: U1.7 (IO3), U2.55 (QSPI_SD3)
/MCU/QSPI_SS: R6.2, R7.1, U2.60 (QSPI_SS)
/MCU/RF_SPI_CS: U2.28 (GPIO17); also elsewhere on the board
/MCU/RF_SPI_MISO: U2.32 (GPIO20); also elsewhere on the board
/MCU/RF_SPI_MOSI: U2.31 (GPIO19); also elsewhere on the board
/MCU/RF_SPI_SCK: U2.29 (GPIO18); also elsewhere on the board
/MCU/SWCLK: J5.1, U2.24 (SWCLK)
/MCU/SWD: J5.2, U2.25 (SWD)
/MCU/VREG_AVDD: C11.1, R1.2, U2.46 (VREG_AVDD)
/MCU/VREG_LX: L1.2, U2.48 (VREG_LX)
/MCU/XIN: C15.2, U2.21 (XIN), Y1.1
/MCU/XOUT: R11.2, U2.22 (XOUT)
/MCU/XOUT_R: C16.2, R11.1, Y1.3
/MCU/~USB_BOOT: R6.1, SW1.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.1, C16.1, D1.1 (K), D2.1 (K), D3.1 (K), J5.3, R10.1, SW1.1, U1.4 (GND), U2.47 (VREG_PGND), U2.61 (GND), Y1.2, Y1.4; also elsewhere on the board
unnamed: D1.2 (A), R12.2
unnamed: D2.2 (A), R13.2
unnamed: D3.2 (A), R14.2
unnamed: R10.2, SW2.1
unnamed: R12.1, U2.4 (GPIO2)
unnamed: R13.1, U2.9 (GPIO6)
unnamed: R14.1, U2.14 (GPIO10)
unnamed: R3.2, U2.51 (USB_DM)
unnamed: R2.2, U2.52 (USB_DP)
USB_D+: R2.1; also elsewhere on the board
USB_D-: R3.1; also elsewhere on the board

Notes on the sheet:
UART TX Indicator LEDs
1V1 Integrated VReg @ max 200mA
Flash
Get line characteristic impedance to 90 ohms
Crystal
Use PIO mode as virtual UART in Software
Make sure these R are close to RP2350
R < 1k for high brightness on sunny field day
why is this 10k?
USB-C Program+Power & 3V3 VReg @ max 1A
Make sure PCB trace is short

Parts:
J7: RF SMA
U9: E22-400M33S; WIRELM-SMD_E22-400M33S; LCSC Part C5352927

Connections:
+5V: U9.9 (VCC), U9.10 (VCC); also elsewhere on the board
/MCU/RF_SPI_CS: U9.19 (NSS); also elsewhere on the board
/MCU/RF_SPI_MISO: U9.16 (MISO); also elsewhere on the board
/MCU/RF_SPI_MOSI: U9.17 (MOSI); also elsewhere on the board
/MCU/RF_SPI_SCK: U9.18 (SCK); also elsewhere on the board
/RF/NRST: U9.15 (NRST)
/RF/RF_ANT: J7.1 (In), U9.21 (ANT)
GND: J7.2 (Ext), U9.1 (GND), U9.2 (GND), U9.3 (GND), U9.4 (GND), U9.5 (GND), U9.11 (GND), U9.12 (GND), U9.20 (GND), U9.22 (GND); also elsewhere on the board

Notes on the sheet:
5V @ 1300mA required
BUSY (status indication, see SX1268 datasheet)
EBYTE Module Note: - TX Current max 1300mA
what are we doing with TXEN, RXEN, BUSY?

Parts:
AE1: Antenna
C31: 100nF; C_0402_1005Metric
C32: 1uF; C_0402_1005Metric
C33: 10uF; C_0402_1005Metric
J8: USB_C_USB2.0_16P; USB_C_Receptacle_Molex_105450-0101
R24, R25: 5k1; R_0402_1005Metric
R26, R27: 27; R_0402_1005Metric
R28: 10k; R_0402_1005Metric
SW5: SW_Push; SW_SPST_B3U-1000P
TP1: TestPoint
U6: NEO-M9N; ublox_NEO

Connections:
+3V3: C31.1, C32.1, C33.1, U6.22 (V_BCKP), U6.23 (VCC); also elsewhere on the board
/GNSS/GNSS_ANT: AE1.1, U6.11 (RF_IN)
/GNSS/SPI_CS: U6.18 (SDA/~SPI_CS); also elsewhere on the board
/GNSS/SPI_MISO: U6.20 (TXD/SPI_MISO); also elsewhere on the board
/GNSS/SPI_MOSI: U6.21 (RXD/SPI_MOSI); also elsewhere on the board
/GNSS/SPI_SCK: U6.19 (SCL/SPI_CLK); also elsewhere on the board
/GNSS/USB2_CC1: J8.A5 (CC1), R25.1
/GNSS/USB2_CC2: J8.B5 (CC2), R24.1
/GNSS/USB2_D+: J8.A6 (D+), J8.B6 (D+), R27.1
/GNSS/USB2_D-: J8.A7 (D-), J8.B7 (D-), R26.1
/GNSS/USB2_DM: R26.2, U6.5 (USB_DM)
/GNSS/USB2_DP: R27.2, U6.6 (USB_DP)
/GNSS/VDD_USB: J8.A4 (VBUS), J8.A9 (VBUS), J8.B4 (VBUS), J8.B9 (VBUS), U6.7 (VDD_USB)
/GNSS/nRESET: SW5.2, U6.8 (~RESET)
GND: C31.2, C32.2, C33.2, J8.A1 (GND), J8.A12 (GND), J8.B1 (GND), J8.B12 (GND), R24.2, R25.2, R28.1, U6.2 (D_SEL), U6.10 (GND), U6.12 (GND), U6.13 (GND), U6.24 (GND); also elsewhere on the board
unnamed: R28.2, SW5.1
unnamed: TP1.1, U6.1 (~SAFEBOOT)

Notes on the sheet:
Leave shield floating
Make sure these R are close to GNSS
USB-C
Buy antenna or microstrip L1?
(EXTINT) Wake up from power saving mode
(SAFEBOOT) For future service, updates and reconfiguration, leave OPEN
(TIMEPULSE)Configurable Timepulse 1 signal (one pulse per second by default).
GNSS

Board: 4 copper layers, 89.7 x 89.7 mm, 88 parts (0 on the bottom side), 68 nets.

## KiCad design drafts/drafts.kicad_pcb

Board: 2 copper layers, 95.5 x 97.5 mm, 144 parts (1 on the bottom side), 85 nets.

Parts:
BT1: Battery_Cell; BatteryHolder_MPD_BH-18650-PC2
C1, C2: 15p; C_0402_1005Metric
C3, C8, C11, C12, C13, C14, C15, C16, C17, C18: 100n; C_0402_1005Metric
C4, C5: 10u; C_0402_1005Metric
C6, C7, C9: 4u7; C_0603_1608Metric
C10: 4u7; C_0402_1005Metric
C19, C19#2, C20, C20#2, C31, C32, C33: 4.7uF; C_0402_1005Metric
C21, C27: 100nF; C_0402_1005Metric
C22, C29, C30: 1uF; C_0402_1005Metric
C23, C24, C25: 10uF; C_0402_1005Metric
C26: 22uF; C_0402_1005Metric
C28: 100uF; C_0402_1005Metric
D1: GREEN; LED_0603_1608Metric
D2, D3, D4, D5#2, D6, D7, D9, D10: LED; LED_0603_1608Metric
D5: SS34; D_SMA
D8: SMAJ6.0CA; D_SMA
D11: SS24; D_SMA
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_Molex_105450-0101
J2: Cube 0 UART; JST_EH_S3B-EH_1x03_P2.50mm_Horizontal
J3: Cube 1 UART; JST_EH_S3B-EH_1x03_P2.50mm_Horizontal
J4: Cube 2 UART; JST_EH_S3B-EH_1x03_P2.50mm_Horizontal
J5: JST Debug Connector; JST_EH_S3B-EH_1x03_P2.50mm_Horizontal
J6: Micro_SD_Card; microSD_HC_Wuerth_693072010801
J8: USB_B_Micro; USB_Micro-B_Molex_47346-0001
L1, L1#2, L2: 3.3u; L_pol_2016
Q2, Q3: FS8205A; SOT-23-6L_TCP
Q4: IRLML6401; SOT-23
R1: DNF; R_0402_1005Metric
R2: 0; R_0402_1005Metric
R3, R18, R19, R20, R21, R22, R23, R24, R30, R31, R32: 10k; R_0402_1005Metric
R4, R5: 5k1; R_0402_1005Metric
R6, R16, R16#2, R17, R26, R27, R33, R34, R35, R36, R37, R38, R39: 1k; R_0402_1005Metric
R7: 1k5; R_0603_1608Metric
R8, R10, R13, R14, R15: 1k; R_0603_1608Metric
R9: 33; R_0603_1608Metric
R11, R12, R28, R29: 27; R_0402_1005Metric
R17#2: 2k; R_0402_1005Metric
R19#2, R40: 100k; R_0402_1005Metric
R25: 4.7k; R_0402_1005Metric
SW1, SW2, SW3: SW_Push; SW_SPST_B3U-1000P
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP14, TP15, TP16, TP17, TP18, TP19, TP20, TP21: TestPoint; TestPoint_Pad_D1.0mm
U1: W25Q128JVS; SOIC-8_5.3x5.3mm_P1.27mm
U2, U7: AMS1117-3.3; SOT-223-3_TabPin2
U3: RP2350_60QFN; RP2350-QFN-60-1EP_7x7_P0.4mm_EP3.4x3.4mm_ThermalVias
U4: MCP73831-2-OT; SOT-23-5
U5: MCP9808_MSOP; MSOP-8_3x3mm_P0.65mm
U6: NEO-M8N; ublox_NEO
U8: E32-433T37_Module
U9: MT3608; SOT-23-6
U10: INA219AxDCN; SOT-23-8
U11: DW01A; SOT-23-6
U12: TP4056-42-ESOP8; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.41x3.3mm_ThermalVias
Y1: ABM8_262_T3; Crystal_SMD_Abracon_ABM8G-4Pin_3.2x2.5mm

Connections:
+1V1: C7.1, C8.1, C9.1, C11.1, L1.1, L1#2.1, TP7.1, TP10.1, U3.6 (DVDD), U3.23 (DVDD), U3.39 (DVDD), U3.50 (VREG_FB)
+3V3: C3.1, C5.1, C6.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C21.1, C22.1, C23.1, C29.1, D1.2 (A), J6.4 (VDD), R3.1, R9.1, R21.1, R23.1, R25.1, TP3.1, TP5.1, TP6.1, TP8.1, TP9.1, TP14.1, TP15.1, TP16.1, TP17.1, TP20.1, U1.8 (VCC), U2.2 (VO), U3.1 (IOVDD), U3.11 (IOVDD), U3.20 (IOVDD), U3.30 (IOVDD), U3.38 (IOVDD), U3.44 (ADC_AVDD), U3.45 (IOVDD), U3.49 (VREG_VIN), U3.53 (USB_OTP_VDD), U3.54 (QSPI_IOVDD), U5.8 (V_{DD}), U6.22 (V_BCKP), U6.23 (VCC), U10.4 (VS)
+5V: C4.1, C19#2.1, D5#2.2 (A), D11.2 (A), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), Q4.1 (G), R34.1, R40.1, TP4.1, TP11.1, TP12.1, U2.3 (VI), U4.4 (V_{DD})
/MCU/FLASH_SS: R1.2, R2.2, R3.2, U1.1 (~CS)
/MCU/QSPI_SCLK: U1.6 (CLK), U3.56 (QSPI_SCLK)
/MCU/QSPI_SD0: U1.5 (DI(IO0)), U3.57 (QSPI_SD0)
/MCU/QSPI_SD1: U1.2 (DO(IO1)), U3.59 (QSPI_SD1)
/MCU/QSPI_SD2: U1.3 (IO2), U3.58 (QSPI_SD2)
/MCU/QSPI_SD3: U1.7 (IO3), U3.55 (QSPI_SD3)
/MCU/QSPI_SS: R2.1, R10.2, U3.60 (QSPI_SS)
/MCU/VREG_AVDD: C10.1, R9.2, U3.46 (VREG_AVDD)
/MCU/VREG_LX: L1.2, L1#2.2, U3.48 (VREG_LX)
/MCU/XIN: C1.2, U3.21 (XIN), Y1.1
/MCU/XOUT: R6.2, U3.22 (XOUT)
/MCU/~USB_BOOT: R10.1, SW1.2
B+: BT1.1 (+), BT1.2 (-), C1.1, C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C19#2.2, C20.2, C20#2.1, C20#2.2, C21.2, C22.2, C23.2, C24.2, C25.2, C29.2, C31.1, C31.2, C32.2, C33.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J2.3, J3.3, J4.3, J5.3, J6.6 (VSS), J6.9 (SHIELD), J8.5 (GND), J8.6 (Shield), Q2.1, Q2.3, Q3.1, Q3.3, Q4.2 (S), R4.2, R5.2, R7.2, R8.1, R13.1, R14.1, R15.1, R17.2, R17#2.2, R20.2, R22.2, R24.2, R26.2, R27.2, R31.2, R33.2, R35.2, R38.2, R39.1, R40.2, SW1.1, U1.4 (GND), U2.1 (GND), U3.47 (VREG_PGND), U3.61 (GND), U4.2 (V_{SS}), U4.3 (V_{BAT}), U5.4 (GND)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
Battery: R18.1, R19.1
EN: R31.1, U6.14 (LNA_EN)
GNSS_CS: U3.33 (GPIO21), U6.18 (SDA/~SPI_CS)
GNSS_MISO: U3.32 (GPIO20), U6.20 (TXD/SPI_MISO)
GNSS_MOSI: U3.35 (GPIO23), U6.21 (RXD/SPI_MOSI)
GNSS_SCK: U3.34 (GPIO22), U6.19 (SCL/SPI_CLK)
IO?: U8.9 (M1), U8.10 (M0)
unnamed: C2.2, R6.1, Y1.3
unnamed: D1.1 (K), R7.1
unnamed: D2.1 (K), R13.2
unnamed: D3.1 (K), R14.2
unnamed: D4.1 (K), R15.2
unnamed: D5.2 (A), L2.2, U9.1 (SW)
unnamed: C20.1, D5.1 (K), D5#2.1 (K), D7.2 (A), R16.1, R16#2.1
unnamed: D6.2 (A), R25.2, U5.3 (Alert)
unnamed: D6.1 (K), R26.1
unnamed: D7.1 (K), R33.1
unnamed: C26.2, C27.2, C28.2, D8.1 (A1), U8.1 (GND), U8.2 (GND)
unnamed: C26.1, C27.1, C28.1, D8.2 (A2), U8.3 (VCC), U8.4 (VCC)
unnamed: D9.2 (A), U12.8 (CE)
unnamed: D9.1 (K), R36.1
unnamed: C32.1, D10.2 (A), R34.2, U12.4 (V_{CC})
unnamed: D10.1 (K), R37.1
unnamed: D11.1 (K), Q4.3 (D)
unnamed: J1.A5 (CC1), R5.1
unnamed: J1.B5 (CC2), R4.1
unnamed: Q2.2, Q3.5
unnamed: R8.2, SW2.1
unnamed: R18.2, R32.1
unnamed: R27.1, SW3.1
unnamed: SW2.2, U3.26 (RUN)
unnamed: R12.1, U3.51 (USB_DM)
unnamed: R11.1, U3.52 (USB_DP)
unnamed: R17#2.1, U4.5 (PROG)
unnamed: R16.2, U4.1 (STAT)
unnamed: R20.1, U5.7 (A0)
unnamed: R22.1, U5.6 (A1)
unnamed: R24.1, U5.5 (A2)
unnamed: R28.2, U6.5 (USB_DM)
unnamed: R29.2, U6.6 (USB_DP)
unnamed: R30.1, U6.7 (VDD_USB)
unnamed: SW3.2, U6.8 (~RESET)
unnamed: C19.1, L2.1, U9.4 (EN), U9.5 (IN)
unnamed: R16#2.2, R17.1, U9.3 (FB)
unnamed: C30.1, R19.2, U10.1 (IN+)
unnamed: C30.2, R32.2, U10.2 (IN-)
unnamed: R38.1, U11.2 (CS)
unnamed: Q2.4, Q3.4, U11.3 (OC)
unnamed: Q2.6, Q3.6, U11.1 (OD)
unnamed: C33.1, R39.2, U11.5 (VCC)
unnamed: R35.1, U12.2 (PROG)
unnamed: R36.2, U12.7 (~CHRG)
unnamed: R37.2, U12.6 (~STDBY)
RX0: J2.2, U3.3 (GPIO1)
RX1: J3.2, U3.8 (GPIO5)
RX2: J4.2, U3.13 (GPIO9)
SCL: R21.2, U5.2 (SCL), U10.5 (SCL)
SDA: R23.2, U5.1 (SDA), U10.6 (SDA)
SWCLK: J5.1, TP1.1, U3.24 (SWCLK)
SWD: J5.2, TP2.1, U3.25 (SWD)
TX0: D2.2 (A), J2.1, U3.2 (GPIO0)
TX1: D3.2 (A), J3.1, U3.7 (GPIO4)
TX2: D4.2 (A), J4.1, U3.12 (GPIO8)
USB_D+: J1.A6 (D+), J1.B6 (D+), R11.2
USB_D-: J1.A7 (D-), J1.B7 (D-), R12.2
USB_DM: J8.2 (D-), R28.1
USB_DP: J8.3 (D+), R29.1
VBUS2: C24.1, J8.1 (VBUS), TP18.1, U7.3 (VI)
VDD_USB: C25.1, R30.2, TP19.1, TP21.1, U7.2 (VO)

## Commit log

2025-06-18 Initial upload
2025-07-03 update gnss
2025-07-04 Update Lipo_GNSS_debug
2025-07-04 real_updated_lipo_gnss_debug
2025-07-04 gnss_lipo_debug
2025-07-04 lipo_gnss_debug
2025-07-05 gnss_lipo_debug_temp
2025-07-05 sensors
2025-07-09 draft
2025-07-09 Power
2025-10-29 Initial BLV_PCB
